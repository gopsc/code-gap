# Keil uVision project vga.uvproj, settings and files
target vga (ARM-ADS)
  device: STM32F103RC STMicroelectronics
  cpu: IRAM(0x20000000-0x2000BFFF) IROM(0x8000000-0x803FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: vga
  c flags: Optim=1 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group u
    ./: startup_stm32f10x_hd.s
    ./things/: library_stm32.h
  group sister
    ./sister/: time.h gpio.h sister_init.h
  group things
    ./things/: Kylin_mini_v1.2.h varilables.h
  group source
    ./source/: vga.c

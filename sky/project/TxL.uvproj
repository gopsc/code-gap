# Keil uVision project TxL.uvproj, settings and files
target target_vga (ARM-ADS)
  device: STM32F103RC STMicroelectronics
  cpu: IRAM(0x20000000-0x2000BFFF) IROM(0x8000000-0x803FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: TxL
  c flags: Optim=1 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group group_base
    ./: startup_stm32f10x_hd.s
  group group_vga
    ./: build.c
